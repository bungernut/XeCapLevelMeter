# Repository bungernut/XeCapLevelMeter

File README.md:

# XeCapLevelMeter

This is a demo board and Arduino code for the AD7151 chip:  https://www.analog.com/en/products/ad7151.html  

The board is purchasable from OSHPark  https://oshpark.com/shared_projects/RMe6ks9J  

The arduino code is based on a Teensy 4.1 with Ethernet serving the data over modbus. 
This is still in development and should be expected to be buggy right now.

## KiCad design PCB/CapLevelSensorAD/CapLevelSensorAD.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 68pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5: 47pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x04_Male; Amphenol Anytech YO 3.81mm 4p; DigikeyPN 609-3920-ND
R1: 39k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 82k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4, R5: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: AD7151; MSOP-10_3x3mm_P0.5mm; DigikeyPN AD7151BRMZ-ND

Connections:
unnamed: C1.1, C2.1, C3.2, C4.2, C5.2, J1.2, J2.1, J3.2, J3.3, U1.1
unnamed: C1.2, C2.2, J1.1, R4.1, R5.1, U1.2
unnamed: C3.1, R1.1, R2.2
unnamed: C4.1, R2.1, U1.4
unnamed: C5.1, R3.1, U1.6
unnamed: J1.3, R4.2, U1.10
unnamed: J1.4, R5.2, U1.9
unnamed: J2.2, U1.7
unnamed: J3.1, R1.2
unnamed: J3.4, R3.2

Notes on the sheet:
SDA
SCL
GND
VDD

Board: 2 copper layers, 38.6 x 23.4 mm, 14 parts (0 on the bottom side), 10 nets.

## KiCad design PCB/TIFDC1004Q_Demo/CapLevelSensorTiFDC1004.kicad_pcb

Board: 2 copper layers, 45.7 x 34.3 mm, 11 parts (0 on the bottom side), 10 nets.

Parts:
-J1+, -J2+, -J3+, -J4+: Conn_01x02_Female; TerminalBlock_Phoenix_PT-1,5-2-3.5-H_1x02_P3.50mm_Horizontal
C1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J5: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
R1, R2: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: FDC1004; VSSOP-10_3x3mm_P0.5mm

Connections:
/GND: C1.2, C2.2, J5.1, U1.7
/SCL: J5.3, R1.1, U1.9
/SDA: J5.4, R2.1, U1.10
/VDD: C1.1, C2.1, J5.2, R1.2, R2.2, U1.8
unnamed: -J1+.1, U1.2
unnamed: -J2+.1, U1.3
unnamed: -J3+.1, U1.4
unnamed: -J4+.1, U1.5
unnamed: R3.2, U1.6
SHLD1: -J1+.2, -J2+.2, -J3+.2, -J4+.2, R3.1, U1.1

## Commit log

2021-08-24 demo board C00 commit
2021-08-25 updating BOM info
2022-01-26 Added Steffen's work for the AD1750
2022-02-17 adding AD KiCAD files
2022-07-22 Create documentation
2022-08-05 Add files via upload
    New code for Capmeter_AD1750. Updated by Steffen.
